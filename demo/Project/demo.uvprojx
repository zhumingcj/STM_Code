# Keil uVision project demo.uvprojx, settings and files
target ZET6 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Lib\F10x_FWLIB\inc;..\User\bsp;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c
  group F10x_FWLIB
    ../Lib/F10x_FWLIB/src/: stm32f10x_gpio.c stm32f10x_rcc.c
  group BSP
    ../User/: led.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
